# Keil uVision project uCOS-III.uvproj, settings and files
target FLASH (6190000::V6.19::ARMCLANG)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: OS
  c flags: Optim=2 v6LangP=5
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\uCOS-III;..\..\BSP;..\..\BSP\OS\uCOS-III;..\..\BSP\ST\STM32\inc;..\..\BSP\KeilMDK;..\..\..\..\..\uC-CPU;..\..\..\..\..\uC-CPU\ARM-Cortex-M3\RealView;..\..\..\..\..\uC-LIB;..\..\..\..\..\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\..\..\..\uCOS-III\Source;..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\BSP\ST\STM32_HAL\Inc;.\FLASH;..\..\BSP\ST\MPU-6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h stm32f10x_conf.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_i2c.c bsp_i2c.h bsp_int.c bsp_periph.c bsp_ser.c bsp_ser.h bsp_stlm75.c bsp_stlm75.h
    ../../BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
    ../../BSP/KeilMDK/: cstartup.s
  group uC/CPU
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../../../../uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../../uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../../../../uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c os_dbg.c
  group uC/OS-III Port
    ../../../../../uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group STM32F1xx Library
    ../../BSP/ST/STM32/inc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_usart.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_wwdg.h stm32f10x_nvic.h stm32f10x_pwr.h
    ../../BSP/ST/STM32/src/: stm32f10x_bkp.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_nvic.c stm32f10x_pwr.c cortexm3_macro.S
  group MPU-6050
    ../../BSP/ST/MPU-6050/: MPU6050.c HAL_MPU6050.h MPU6050.h USR_INIT.c USR_INIT.h
